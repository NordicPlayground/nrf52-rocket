# Keil uVision project nrf52_strato.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD  NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_RTT=1 NRF52 CONFIG_NFCT_PINS_AS_GPIOS DEBUG SOFTDEVICE_PRESENT SWI_DISABLE0 EMPL_TARGET_NRF52
  c include: ..\config;..\sdk_components\ble\ble_services\ble_lbs;..\sdk_components\ble\common;..\sdk_components\drivers_nrf\common;..\sdk_components\drivers_nrf\config;..\sdk_components\drivers_nrf\delay;..\sdk_components\drivers_nrf\gpiote;..\sdk_components\drivers_nrf\hal;..\sdk_components\drivers_nrf\uart;..\sdk_components\libraries\button;..\sdk_components\libraries\fifo;..\sdk_components\libraries\timer;..\sdk_components\libraries\uart;..\sdk_components\libraries\util;..\sdk_components\softdevice\common\softdevice_handler;..\sdk_components\softdevice\s132\headers;..\sdk_components\softdevice\s132\headers\nrf52;..\sdk_components\toolchain;..\sdk_external\segger_rtt;..\include;..\sdk_components\drivers_nrf\timer;..\sdk_components\drivers_nrf\ppi;..\sdk_components\drivers_nrf\saadc;..\include\drivers;..\sdk_components\drivers_nrf\twi_master;..\libs\eMD6\core\driver\eMPL;..\sdk_components\libraries\scheduler;..\include\modules;..\sdk_components\libraries\low_power_pwm;..\include\ble_services;..\sdk_components\drivers_nrf\pwm;..\sdk_components\drivers_nrf\clock
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_RTT=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002278 size 0xdd88
  group Application
    ../: main.c
  group nRF_BLE
    ../sdk_components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../sdk_components/drivers_nrf/delay/: nrf_delay.c
    ../sdk_components/drivers_nrf/common/: nrf_drv_common.c
    ../sdk_components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../sdk_components/libraries/util/: nrf_log.c
    ../sdk_components/drivers_nrf/timer/: nrf_drv_timer.c
    ../sdk_components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../sdk_components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../sdk_components/drivers_nrf/hal/: nrf_saadc.c
    ../sdk_components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../sdk_components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../sdk_components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Libraries
    ../sdk_components/libraries/button/: app_button.c
    ../sdk_components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../sdk_components/libraries/fifo/: app_fifo.c
    ../sdk_components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../sdk_components/libraries/scheduler/: app_scheduler.c
    ../sdk_components/libraries/low_power_pwm/: low_power_pwm.c
  group nRF_Segger_RTT
    ../../../../nRF5_SDK_11.0.0_89a8197/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../sdk_components/softdevice/s132/doc/: s132_nrf52_2.0.0_licence_agreement.txt
    ../sdk_components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Modules
    ../source/modules/: strato_ignition.c strato_led.c strato_ble_ctrl_sys.c strato_parachute_fins.c strato_sensors.c
  group Drivers
    ../source/drivers/: drv_led.c drv_humid_temp.c drv_htu21d.c drv_mpu9250.c drv_pressure_mpl3115A2.c drv_sky66112_pa_lna.c drv_servo.c
  group BLE_Services
    ../source/ble_services/: ble_sts.c ble_srs.c
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\experimental_ble_app_blinky_s132_pca10040;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
